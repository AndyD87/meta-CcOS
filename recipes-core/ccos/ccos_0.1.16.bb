require ccos.inc

SRCREV="746259efc26c6c2a25d8058547f252fcaee720cb"
